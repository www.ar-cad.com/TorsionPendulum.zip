# Autodesk Inventor assembly: torsionPendulum
## iProperties
Created: 2009-11
Part Number: torsionPendulum
Document SubType Name: Assembly
Designer: Lochan
Author: Lochan
